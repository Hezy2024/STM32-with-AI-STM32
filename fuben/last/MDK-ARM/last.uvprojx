# Keil uVision project last.uvprojx, settings and files
target last (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H742IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2405FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: last +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H742xx
  c include: ../Core/Inc;../X-CUBE-AI/App;../X-CUBE-AI;../Middlewares/ST/AI/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x60000
  scatter file: last.sct
  group Application/MDK-ARM
    ./: startup_stm32h742xx.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: network.c network_data.c network_data_params.c aiSystemPerformance.c aiTestHelper.c aiTestUtility.c ai_device_adaptor.c lc_print.c syscalls.c app_x-cube-ai.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c memorymap.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: network_generate_report.txt
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime810_CM7_Keil.lib
software components: CMSIS:CORE 4.3.0
